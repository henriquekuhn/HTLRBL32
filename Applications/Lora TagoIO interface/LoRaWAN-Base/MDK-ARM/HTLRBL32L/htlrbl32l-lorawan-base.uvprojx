# Keil uVision project htlrbl32l-lorawan-base.uvprojx, settings and files
target htlrbl32l-lorawan-base (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.2.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x10040000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: htlrbl32l-lorawan-base +hex
  AfterMake: fromelf.exe --bin Objects\htlrbl32l-lorawan-base.axf --output Objects\htlrbl32l-lorawan-base.bin
  AfterMake: fromelf.exe --bin Objects\htlrbl32l-lorawan-base.axf --output ..\..\..\binaries\htlrbl32l-lorawan-base.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CONFIG_HW_HSE_TUNE=32 CONFIG_HW_SMPS_10uH CONFIG_HW_LS_RO DEFAULT_REGION=8
  c include: ..\..\Inc;..\..\..\HTLRBL32L-SDK\Drivers\BSP\Components\lsm6dsox_STdC\driver;..\..\..\HTLRBL32L-SDK\Drivers\BSP\Components\lps22hh_STdC\driver;..\..\..\HTLRBL32L-SDK\Middlewares\ST\hal\inc;..\..\..\HTLRBL32L-SDK\Drivers\CMSIS\Include;..\..\..\HTLRBL32L-SDK\LoRaWAN\lorawan_specifics\Core;..\..\..\HTLRBL32L-SDK\LoRaWAN\lorawan_specifics\Crypto;..\..\..\HTLRBL32L-SDK\LoRaWAN\lorawan_specifics\Mac;..\..\..\HTLRBL32L-SDK\LoRaWAN\lorawan_specifics\Mac\region;..\..\..\HTLRBL32L-SDK\LoRaWAN\Utils;..\..\..\HTLRBL32L-SDK\LoRaWAN\sx126x;..\..\..\HTLRBL32L-SDK\Drivers\Peripherals_Drivers\inc;..\..\..\HTLRBL32L-SDK\Drivers\BSP\Common\Inc;..\..\..\HTLRBL32L-SDK\Drivers\CMSIS\Device\ST\BlueNRG_LP\Include
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\BlueNRG_LP.sct
  link misc: --verbose
  group Application/User
    ../../Src/: main.c spi.c uart.c rtc.c lorawan_setup.c bluenrg_lp_hal_msp.c bluenrg_lp_it.c i2c.c ht_sensors.c
  group Libraries/LoRaWAN/Core
    ../../../HTLRBL32L-SDK/LoRaWAN/lorawan_specifics/Core/: lora.c lora-test.c
  group Libraries/LoRaWAN/Crypto
    ../../../HTLRBL32L-SDK/LoRaWAN/lorawan_specifics/Crypto/: aes.c cmac.c soft-se.c
  group Libraries/LoRaWAN/MAC
    ../../../HTLRBL32L-SDK/LoRaWAN/lorawan_specifics/Mac/: LoRaMac.c LoRaMacAdr.c LoRaMacClassB.c LoRaMacCommands.c LoRaMacConfirmQueue.c LoRaMacCrypto.c LoRaMacParser.c LoRaMacSerializer.c
  group Libraries/LoRaWAN/MAC/Region
    ../../../HTLRBL32L-SDK/LoRaWAN/lorawan_specifics/Mac/region/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionRU864.c RegionUS915.c
  group Libraries/sx126x
    ../../../HTLRBL32L-SDK/LoRaWAN/sx126x/: radio.c sx126x.c sx1262_interface.c
  group Libraries/Utils
    ../../../HTLRBL32L-SDK/LoRaWAN/Utils/: hal_wrappers.c systime.c timeServer.c utils.c
  group Libraries/Peripheral_Drivers
    ../../../HTLRBL32L-SDK/Drivers/Peripherals_Drivers/src/: rf_driver_hal.c rf_driver_hal_adc.c rf_driver_hal_cortex.c rf_driver_hal_dma.c rf_driver_hal_exti.c rf_driver_hal_flash.c rf_driver_hal_gpio.c rf_driver_hal_rcc.c rf_driver_hal_rtc.c rf_driver_hal_spi.c rf_driver_hal_tim.c rf_driver_hal_uart.c rf_driver_hal_flash_ex.c rf_driver_hal_rtc_ex.c rf_driver_hal_uart_ex.c rf_driver_hal_i2c.c rf_driver_hal_i2c_ex.c
  group Libraries/CMSIS
    ../../../HTLRBL32L-SDK/Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c
software components: CMSIS:CORE 5.3.0
